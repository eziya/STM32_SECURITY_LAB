# IAR project G0_AppIntProt.ewp, settings and files
configuration G0_AppIntProt (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G071xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ..\BSP\STM32G0xx_Nucleo; ..\App\Inc; ..\Hash_Auth\Inc; ..\STM32_Cryptographic\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: G0_AppIntProt.bin
  ILINK.IlinkOutputFile: G0_AppIntProt.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User
    ../App/Src/: app.c
    ../Hash_Auth/Src/: hashcheck.c securitycheck.c
    ../Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Drivers/BSP
    ../BSP/STM32G0xx_Nucleo/: com.c stm32g0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_rcc.c
  group Middleware/Cryptolib
    ../STM32_Cryptographic/Lib/: STM32CryptographicV3.1.3_CM0PLUS_IARv8.a
