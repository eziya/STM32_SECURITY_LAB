<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\G0_AppIntProt.ewp</path>
  </project>
  <batchBuild />
</workspace>
